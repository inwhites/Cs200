# Keil uVision project Library_Stm32f407.uvprojx, settings and files
target Library_Stm32f407 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Library_Stm32f407
  c flags: Optim=1 oTime=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER STM32F4XX
  c include: .\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Project;.\Project\Functions\inc;.\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\Libraries\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./Project/: main.c stm32f4xx_it.c
  group MDK_ARM
    ./Project/: system_stm32f4xx.c
  group Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Start_Up
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Function
    ./Project/Functions/src/: Delay.c LED.c Usart.c Key_4x4.c PWM.c US_100.c EXIT.c TIM.c List_LCD.c LCD.c LCD_Functions.c IIC.c Test_Functions.c Calculate_H_Time.c US_100_H_Time.c NRF24L01.c NRF24L01_module2.c spi.c spi1.c st7735r.c
  group Header
    ./Project/Functions/inc/: Include.h Delay.h LED.h Usart.h Key_4x4.h PWM.h US_100.h EXIT.h TIM.h Bit_LCD.h LCD.h List_LCD.h LCD_Functions.h IIC.h Test_Functions.h Calculate_H_Time.h US_100_H_Time.h NRF24L01.h NRF24L01_module2.h spi.h spi1.h gpio.h st7735r.h COLOR.h font.h
